# Keil uVision project TcpIpTest.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TcpIpTest
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: .\RTE;.\RTE\Device\STM32F407VETx;.\FreeRTOS\include;.\FreeRTOS-Plus-TCP\include;.\User\include;E:\stm32software\ARM\Pack\Keil\STM32F4xx_DFP\2.9.0\CMSIS\Driver
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c netInfoConfig.c randomNum.c
  group FreeRTOS
    ./FreeRTOS/: list.c port.c queue.c tasks.c timers.c event_groups.c heap_4.c
  group FreeRTOS-Plus-TCP
    ./FreeRTOS-Plus-TCP/: FreeRTOS_ARP.c FreeRTOS_Stream_Buffer.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c NetworkInterface.c BufferAllocation_2.c
software components: CMSIS:CORE 5.0.1, CMSIS Driver:Ethernet MAC 2.6, CMSIS Driver:Ethernet PHY:DP83848C 6.1.0, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:RNG 1.5.0, Device:Startup 2.5.0
